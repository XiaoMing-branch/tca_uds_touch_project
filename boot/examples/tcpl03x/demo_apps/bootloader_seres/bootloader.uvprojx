# Keil uVision project bootloader.uvprojx, settings and files
target bootloader_seres (6160000::V6.16::ARMCLANG)
  device: TCPL03 TinyChip
  pack: TinyChip.TCxx_DFP.1.1.1
  cpu: IRAM(0x10000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader_seres +hex
  AfterMake: fromelf -c ./Objects/@H.axf -o ./Objects/@H.txt
  AfterMake: fromelf --m32combined --output=$L@L.s19 !L
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __TCPL03X__,TCAE10X,LIN_TX_QUEUE_SIZE=8
  c include: ..\..\..\..\middleware\log_manager\inc;..\..\..\..\platform\drivers\tcpl03x_ll_driver\inc;..\..\..\..\platform\drivers\tcpl03x_ll_driver\inc\reg;..\..\..\..\platform\devices\tcpl03x\inc;..\..\..\..\platform\pal\pal_systick\inc;..\..\..\..\platform\pal\pal_lin\inc;..\..\..\..\platform\pal\utilities\inc;..\..\..\..\platform\pal\pal_log\inc;..\..\..\..\platform\pal\pal_store\inc;..\..\..\..\platform\CMSIS\Core\Include;.\include;..\..\..\..\platform\pal\pal_wdg\inc;..\..\..\..\platform\devices\tcpl03x\armcc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: ..\..\..\..\platform\devices\tcpl03x\armcc\tcpl03x_normal.sct
  link misc: --entry=Reset_Handler
  group app
    ./source/: app.c aes_cmac.c
  group middleware
    ../../../../middleware/log_manager/: logging.c tc_printf.c
    ./source/: dfu_uds_manager.c
  group platform/device
    ../../../../platform/devices/tcpl03x/armcc/: startup_tcpl03x.s
    ../../../../platform/devices/tcpl03x/: system_tcpl03x.c
  group platform/driver
    ../../../../platform/drivers/tcpl03x_ll_driver/: tcpl03x_ll_cortex.c tcpl03x_ll_gpio.c tcpl03x_ll_sci.c tcpl03x_ll_sys.c tcpl03x_ll_wdg.c
    ./source/: tcpl03x_ll_flash_cus.c
  group platform/pal
    ../../../../platform/pal/pal_lin/: pal_lin_comm.c
    ../../../../platform/pal/pal_log/: pal_log.c
    ../../../../platform/pal/pal_store/: pal_store.c
    ../../../../platform/pal/pal_systick/: pal_systick.c
    ../../../../platform/pal/utilities/: utilities.c
    ../../../../platform/pal/pal_wdg/: pal_wdg.c
    ./source/: pal_lin_tl_slv_cus.c
  group readme
    ./: readme.txt
